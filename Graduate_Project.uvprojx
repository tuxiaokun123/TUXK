# Keil uVision project Graduate_Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Graduate_Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Blockset;.\Hardware;.\Library_Header;.\Startup;.\System;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Startup/: air32f10x.h core_cm3.c core_cm3.h misc.c misc.h startup_air32f10x.s
  group System
    ./System/: AIR32.c AIR32.h E_Meter_CRT.c E_Meter_CRT.h exti.c exti.h stmflash.c stmflash.h sys.c sys.h system_air32f10x.c system_air32f10x.h usart.c usart.h delay.c delay.h IWDG.c IWDG.h
  group Library
    ./Library/: air32f10x_adc.c air32f10x_bkp.c air32f10x_can.c air32f10x_cec.c air32f10x_crc.c air32f10x_dac.c air32f10x_dbgmcu.c air32f10x_dma.c air32f10x_exti.c air32f10x_flash.c air32f10x_fsmc.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_iwdg.c air32f10x_otp.c air32f10x_pwr.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_rtc.c air32f10x_sdio.c air32f10x_spi.c air32f10x_tim.c air32f10x_trng.c air32f10x_usart.c air32f10x_wwdg.c
  group Library_Header
    ./Library_Header/: air32f10x_adc.h air32f10x_bkp.h air32f10x_can.h air32f10x_cec.h air32f10x_crc.h air32f10x_dac.h air32f10x_dbgmcu.h air32f10x_dma.h air32f10x_exti.h air32f10x_flash.h air32f10x_fsmc.h air32f10x_gpio.h air32f10x_i2c.h air32f10x_iwdg.h air32f10x_otp.h air32f10x_pwr.h air32f10x_rcc.h air32f10x_rcc_ex.h air32f10x_rtc.h air32f10x_sdio.h air32f10x_spi.h air32f10x_tim.h air32f10x_trng.h air32f10x_usart.h air32f10x_wwdg.h
  group Bloockset
    ./Blockset/: BC260Y.c BC260Y.h HLW8110.c HLW8110.h
  group Hardware
    ./Hardware/: Battery.c Battery.h Font.h GUI.c GUI.h LCD_Config.h LCD_Displayinformation.c LCD_Displayinformation.h Lcd_Driver.c Lcd_Driver.h Power_EN.c Power_EN.h Relay.c Relay.h timer.c timer.h
  group User
    ./User/: air32f10x_conf.h air32f10x_it.c air32f10x_it.h main.c test.h
